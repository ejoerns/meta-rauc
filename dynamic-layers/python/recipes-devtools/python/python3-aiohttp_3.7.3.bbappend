RDEPENDS_${PN} += "\
    ${PYTHON_PN}-typing-extensions \
"
