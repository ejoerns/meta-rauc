require rauc-target.inc
require rauc-git.inc
